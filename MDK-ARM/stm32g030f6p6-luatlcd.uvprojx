# Keil uVision project stm32g030f6p6-luatlcd.uvprojx, settings and files
target stm32g030f6p6-luatlcd (6180000::V6.18::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: stm32g030f6p6-luatlcd +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=6 v6LangP=5 wLevel=3
  c define: STM32G030xx,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User/Core
    ../Core/Src/: lcd.c main.c gpio.c spi.c stm32g0xx_it.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_utils.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_spi.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_ll_pwr.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
software components: Acceleration:Arm-2D Helper:PFB 1.3.0, Acceleration:Arm-2D:Alpha-Blending 1.0.0-preview, Acceleration:Arm-2D:Core 1.0.0-preview, Acceleration:Arm-2D:Transform 1.0.0-preview, CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0
